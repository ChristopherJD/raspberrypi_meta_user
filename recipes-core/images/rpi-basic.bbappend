IMAGE_INSTALL += " network-conf"
IMAGE_INSTALL += " ssh-conf"
IMAGE_INSTALL += " hello-world"
