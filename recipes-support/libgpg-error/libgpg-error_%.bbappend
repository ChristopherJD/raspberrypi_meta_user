FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
	file://0001-gawk5-support.patch \
	file://0002-gawk5-support.patch"

